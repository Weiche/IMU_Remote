# Keil uVision project lpc812_mpu6050.uvprojx, settings and files
target LPC812 (ARM-ADS)
  device: LPC812M101 NXP
  cpu: IROM(0x00000000,0x4000) IRAM(0x10000000,0x1000) IRAM2(0x2007C000,0x4000) CPUTYPE("Cortex-M0+") CLOCK(30000000) ELITTLE
  output: lpc812_mpu6050
  c flags: Optim=3 uC99=1 wLevel=2
  c define: MPU6050,EMPL_LPC812,NRF24_HAL_LPC8xx
  c include: ..\lpc800_driver_lib\inc;..\LPC812_MPU6050;.\driver\eMPL;..\xprintf;.\driver\NRF24L01P;.\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x10000000 size 0x1000
  memory RVCT10: RAM 0x2007c000 size 0x4000
  group User
    ./: lpc812_mpu6050.map
    ../xprintf/: xprintf.c
    ../lpc800_driver_lib/src/: lpc8xx_pinint.c
    ./user/: low_power.c main.c mpu6050.c pin_setting.c radio_serial.c
  group Driver_I2C
    ./driver/: Driver_I2C_LPC81x.c
  group Driver_MPU6050
    ./driver/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group Driver_NRF24
    ./driver/NRF24L01P/: nrf24l01.c
    ./driver/NRF24L01P/hal/: nrf24l01_hal_lpc810.c
  group ::Device
    RTE/Device/LPC812M101/: startup_LPC8xx.s system_LPC8xx.c
software components: CMSIS:CORE 3.20.0, Device:Startup 1.0.0
